# IAR project SimpleBLECentral.ewp, settings and files
configuration CC2541EM (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: xALLOW_BLE_ADV; HW_VERN=1; GDE_DEV_ID=9; GME_DEV_ID=1001; VERSION_NUMBER=0x0100; xTEN_DEBUG_MODE; xTEST_433; xCC1120; xUSE_CC112X_RF; xSPI_USE_DMA; xHAL_UART_SPI=2; xHAL_SPI_MASTER; xHAL_UART_PORT=1; POWER_SAVING; INT_HEAP_LEN=2000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_DMA=TRUE; HAL_UART_ISR=1; HAL_UART_DMA=2; DMA_PM=FALSE; HAL_LED=FALSE; HAL_UART=TRUE; HAL_I2C=TRUE; HAL_ADC=TRUE; HAL_I2C_MASTER; HAL_KEY=FALSE; HAL_LCD=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Include; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration GDE_RELEASE (8051)
  as the first configuration, except:
  ICC8051.CCDefines: GDE_DEV_ID=7; GME_DEV_ID=1001; VERSION_NUMBER=0x0100; xGME_WORKING; GM_TEST_COMM; xALLOW_DEBUG_OUTPUT; xUSE_BLE_STACK; HW_VERN=1; USE_CC112X_RF; HAL_UART_PORT=1; HAL_UART_SPI=2; HAL_SPI_MASTER; POWER_SAVING; INT_HEAP_LEN=1500; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_DMA=TRUE; HAL_UART_ISR=1; HAL_UART_DMA=2; DMA_PM=FALSE; HAL_LED=FALSE; HAL_UART=TRUE; HAL_I2C=TRUE; HAL_ADC=TRUE; HAL_I2C_MASTER; HAL_KEY=FALSE; HAL_LCD=FALSE
  postbuild: "..\..\common\cc2540\cc254x_sim2bin.exe" "GDE_RELEASE\Exe\GDE_release.sim" "GDE_RELEASE\Exe\GDE_release.bin"
configuration GTE_RELEASE (8051)
  as the first configuration, except:
  ICC8051.CCDefines: xALLOW_DEBUG_OUTPUT; NOT_USE_BLE_STACK; xTEN_DEBUG_MODE; xCC1120; HW_VERN=1; GDE_DEV_ID=10; GME_DEV_ID=1001; VERSION_NUMBER=0x0100; xTEST_433; xUSE_CC112X_RF; xSPI_USE_DMA; xHAL_UART_SPI=2; xHAL_SPI_MASTER; xHAL_UART_PORT=1; POWER_SAVING; IMAGE_VERSION_NUM=1; INT_HEAP_LEN=2000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_DMA=TRUE; HAL_UART_ISR=1; HAL_UART_DMA=2; DMA_PM=FALSE; HAL_LED=FALSE; HAL_UART=TRUE; HAL_I2C=TRUE; HAL_ADC=TRUE; HAL_I2C_MASTER; HAL_KEY=FALSE; HAL_LCD=FALSE
configuration GDE_SMTK_RELEASE (8051)
  as the first configuration, except:
  ICC8051.CCDefines: GM_TEST_COMM; NOT_USE_BLE_STACK; xALLOW_DEBUG_OUTPUT; xTEN_DEBUG_MODE; HW_VERN=1; GDE_DEV_ID=21; GME_DEV_ID=1001; VERSION_NUMBER=0x0100; POWER_SAVING; IMAGE_VERSION_NUM=1; INT_HEAP_LEN=2000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_DMA=TRUE; HAL_UART_ISR=1; HAL_UART_DMA=2; DMA_PM=FALSE; HAL_LED=FALSE; HAL_UART=TRUE; HAL_I2C=TRUE; HAL_ADC=TRUE; HAL_I2C_MASTER; HAL_KEY=FALSE; HAL_LCD=FALSE; xUSE_CC112X_RF; xHAL_UART_SPI=2; xHAL_SPI_MASTER; xHAL_UART_PORT=1
  group APP
    ../Source/: BLECore.c BLECore.h BLECore_Main.c Cc112x.c Cc112x.h Com433.c Com433.h GMProc.c GMProc.h OSAL_BLECore.c Pktfmt.c Pktfmt.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_i2c.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_i2c.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_bcast.lib CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi.h npi_spi.c npi_uart.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
