# IAR project SimpleBLECentral.ewp, settings and files
configuration CC2541EM (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: IMAGE_VERSION_NUM=1; BLE_BEACON; xCARDROID; xCARD; xIO_DETECT; xBLE_BASE; xSCAN_DEBUG; xOAD_UPGRADE; POWER_SAVING; INT_HEAP_LEN=2000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_LED=FALSE; HAL_UART=FALSE; DMA_PM=FALSE; xHAL_UART_ISR=0; HAL_I2C=FALSE; xHAL_I2C_MASTER; HAL_ADC=TRUE; HAL_KEY=FALSE; HAL_LCD=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Include; ..\..\Profiles\Roles
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration BLE_BEACON_IMG (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: BLE_BEACON; OAD_UPGRADE; HAL_IMAGE_B; POWER_SAVING; xSCAN_DEBUG; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=2000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; DMA_PM=FALSE; HAL_UART_ISR=0; HAL_ADC=TRUE; HAL_LED=FALSE; HAL_I2C=FALSE; HAL_KEY=FALSE; HAL_LCD=FALSE
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_sim2bin.exe" "BLE_BEACON_IMG\Exe\Blebeacon.sim" "BLE_BEACON_IMG\Exe\Blebeacon.bin"
  XLINK.XclFile: ..\Source\cc254x_f256_imgB_Large.xcl
configuration CARDROID_IMG (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CARDROID; CARD; xIMAGE_VERSION_NUM=1; POWER_SAVING; xSCAN_DEBUG; OAD_UPGRADE; HAL_IMAGE_B; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=2000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; DMA_PM=FALSE; HAL_UART_ISR=0; HAL_LED=TRUE; BLINK_LEDS; HAL_I2C=TRUE; HAL_I2C_MASTER; HAL_ADC=TRUE; HAL_KEY=FALSE; HAL_LCD=FALSE
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_sim2bin.exe" "CARDROID_IMG\Exe\Cardroid.sim" "CARDROID_IMG\Exe\Cardroid.bin"
  XLINK.XclFile: ..\Source\cc254x_f256_imgB_Large.xcl
configuration BLE_BASE_IMG (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: BLE_BASE; OAD_UPGRADE; HAL_IMAGE_B; xPOWER_SAVING; xSCAN_DEBUG; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=2000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; DMA_PM=FALSE; HAL_UART_ISR=0; HAL_LED=TRUE; HAL_ADC=FALSE; HAL_I2C=FALSE; HAL_KEY=FALSE; HAL_LCD=FALSE
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_sim2bin.exe" "BLE_BASE_IMG\Exe\BleBase.sim" "BLE_BASE_IMG\Exe\BleBase.bin"
  XLINK.XclFile: ..\Source\cc254x_f256_imgB_Large.xcl
configuration IO_DETECT_IMG (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: IO_DETECT; xPOWER_SAVING; SCAN_DEBUG; OAD_UPGRADE; HAL_IMAGE_B; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=2000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; DMA_PM=FALSE; HAL_UART_ISR=0; HAL_ADC=TRUE; HAL_LED=TRUE; BLINK_LEDS; HAL_I2C=FALSE; HAL_KEY=FALSE; HAL_LCD=FALSE
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_sim2bin.exe" "IO_DETECT_IMG\Exe\IODetect.sim" "IO_DETECT_IMG\Exe\IODetect.bin"
  XLINK.XclFile: ..\Source\cc254x_f256_imgB_Large.xcl
configuration CC2540EM (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: as above
  ICC8051.CCDefines: xIMAGE_VERSION_NUM=1; xBLE_BEACON; xCARDROID; xCARD; xIO_DETECT; BLE_BASE; xSCAN_DEBUG; xOAD_UPGRADE; xPOWER_SAVING; INT_HEAP_LEN=2000; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_UART=TRUE; DMA_PM=FALSE; HAL_UART_ISR=0; xHAL_I2C=TRUE; HAL_ADC=TRUE; HAL_KEY=FALSE; xHAL_I2C_MASTER
  ICC8051.CCOptLevel: 3
  group APP
    ../Source/: OSAL_UPLBSApp.c UPLBSAcc.c UPLBSAcc.h UPLBSApp.c UPLBSApp.h UPLBSApp_Main.c UPLBSPacket.h UPLBSprofile.c UPLBSprofile.h UPLBSSerial.c UPLBSSerial.h UPLBSUpgrade.c UPLBSUpgrade.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/Driver
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_aes.h hal_board_cfg.h hal_ccm.h hal_crc.c hal_crc.h hal_dma.c hal_dma.h hal_flash.c hal_i2c.c hal_i2c.h hal_key.c hal_lcd.c hal_led.c hal_mcu.h hal_sleep.c hal_startup.c hal_timer.c hal_types.h hal_uart.c
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h ll_sleep.h phy.h
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_BLE.lib
    ../../Libraries/CC2541DB/bin/: CC2541_BLE.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Roles/: central.c central.h gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
