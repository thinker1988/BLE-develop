# IAR project BIM.ewp, settings and files
configuration CC254xF256 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: HAL_UART_SBL=1; SBL_UART_PORT=HAL_UART_PORT_0
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\app; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\..\Components\osal\include
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  postbuild: "..\..\..\common\cc2540\cc254x_sim2bin.exe" "CC254xF256\Exe\bim&sbl.sim" "CC254xF256\Exe\bim&sblApp.bin"
  XLINK.XclFile: im&sbl_cc254x.xcl
  group APP
    ../app/: im&sbl_exec.c im&sbl_exec.h im&sbl_ivec.s51 im&sbl_main.c
  group HAL
    ../../../../../Components/hal/target/CC2540EB/: hal_flash.c
    ../../../../../Components/hal/include/: hal_flash.h
